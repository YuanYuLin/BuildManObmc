OBMC_IMAGE_EXTRA_INSTALL += " phosphor-power"
IMAGE_INSTALL += " phosphor-power"
