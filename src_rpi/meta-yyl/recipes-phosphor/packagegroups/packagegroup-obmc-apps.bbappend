
RDEPENDS:${PN}-extras:append = " \
                               entity-manager \
                               "

